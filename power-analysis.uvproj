# Keil uVision project power-analysis.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: power-analysis
  BeforeMake: Z:\before_build.bat
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    Z:/: main.asm
    Z:/dispLCD/: dispLCD.LIB
